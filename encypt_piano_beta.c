#include "stdio.h"
int main(){
    int input[3],num=0;
    int let[26][3] = {{1,2,1},{1,2,3},{1,2,4},{1,3,1},
                      {1,3,2},{1,3,4},{1,4,1},{1,4,2},
                      {1,4,3},{2,1,2},{2,1,3},{2,1,4},
                      {2,3,1},{2,3,2},{2,3,4},{2,4,1},
                      {2,4,2},{2,4,3},{3,1,2},{3,1,3},
                      {3,1,4},{3,2,1},{3,2,3},{3,2,4},
                      {4,1,2},{4,1,3},{4,1,4}};
    char letter[4] = {'A','B','C','D','E','F','G','H','I','J','K','L','M','N','O','P','Q','R','S','T','U','V','W','X','Y','Z',' '};
    for(int i=0;i<3;i++){
        scanf("%d",&input[i]);
    }
    for (int i=0;i<26;i++){
      int count = 0;
      for (int j=0;j<3;j++){
        if (input[j] == let[i][j]){
          count += 1;
        }
      }
      if (count == 3){
        printf("%c",letter[num]);
      }
      else{
        num+=1;
      }
    }
}